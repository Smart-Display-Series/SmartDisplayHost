# Keil uVision project SmartDisplayHost.uvprojx, settings and files
target SmartDisplayHost (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SmartDisplayHost +hex
  AfterMake: fromelf #L --bin --output=..\Doc\
  AfterMake: ..\Doc\generate_bin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../TouchGFX/target;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/images/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../middlewares/st/touchgfx/touchgfx/framework/include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\Drivers\BSP\Components\w25q128;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/BSP/Components/Common;../Drivers/CMSIS/Include;../middlewares/st/touchgfx/touchgfx/framework/include;..\Middlewares\CanOpen\Inc
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: SmartDisplayHost\SmartDisplayHost.sct
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c canopentask.c SmartDisplayHost.c crc.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp touchgfx_gpio.cpp STM32F4DMA.cpp STM32F4HAL.cpp STM32F4TouchController.cpp STM32F4Instrumentation.cpp HW_Init.cpp
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/w25q128/: w25q128jv.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/TouchGFX
    ../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Application/User/TouchGFX/gui
    ../touchgfx/gui/src/containers/: customcontainer1.cpp scrolllistcontainer.cpp scrollselect.cpp scrollunselect.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/monitor_screen/: monitorpresenter.cpp monitorview.cpp
    ../touchgfx/gui/src/setting_screen/: settingpresenter.cpp settingview.cpp
  group Application/User/TouchGFX/generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_verdana_10_4bpp_0.cpp font_xolonium_regular_otf_50_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_xolonium_regular_otf_50_4bpp.cpp table_verdana_10_4bpp.cpp table_xolonium_regular_otf_50_4bpp.cpp
    ../touchgfx/generated/images/src/: base_screen.cpp battery_0.cpp battery_1.cpp bitmapdatabase.cpp button1_0.cpp button1_1.cpp button_10.cpp button_3.cpp button_8.cpp button_9.cpp carbon_fibre.cpp circleprogress_0.cpp circleprogress_1.cpp gauge_1.cpp gauge_2.cpp gauge_5.cpp graph_0.cpp groupbutton_0.cpp horizontalslider_0.cpp imageprogress_0.cpp imageprogress_1.cpp indicator_0.cpp indicator_1.cpp indicator_2.cpp reserved.cpp silde_1.cpp silde_2.cpp temperature.cpp togglebutton_1_0.cpp togglebutton_1_1.cpp verticalslider_0.cpp widget-menu_21-01.cpp widget-menu_21-02.cpp
    ../touchgfx/generated/gui_generated/src/containers/: customcontainer1base.cpp scrolllistcontainerbase.cpp scrollselectbase.cpp scrollunselectbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/monitor_screen/: monitorviewbase.cpp
    ../touchgfx/generated/gui_generated/src/setting_screen/: settingviewbase.cpp
  group Middlewares/CanOpen
    ../Middlewares/CanOpen/Src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c CanOpenTimeBase.lib
software components: CMSIS:CORE 5.1.1
